# Keil uVision project ssp32.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ssp32
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: C:\Keil\ARM\ARMCC\include;C:\Keil\ARM\INC\ST\STM32F10x;..\User\inc;..\Lib\cmsis;..\Lib\inc;..\Lib\startup\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --libpath "C:\Keil\ARM\ARMCC\lib"
  group User
    ../User/src/: delay.c key.c led.c main.c stm32f10x_it.c sys.c usart.c cJSON.c malloc.c Com4004.c timer.c Com1010.c list.c sensors.c sensors_adc.c sensors_gpio.c sensors_i2c_hal.c sensors_sht3x.c sensors_timer.c sensors_uart.c
  group StdPeriph_Driver
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Lib/cmsis/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
